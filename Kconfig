## Kconfig
```kconfig
config BBQUE_SCHEDPOL_ADAPTIVECPU
  bool "AdaptiveCPU"
  default n
  ---help---
  Description...
```
